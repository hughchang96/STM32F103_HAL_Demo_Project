# Keil uVision project LED.uvprojx, settings and files
target LED (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: LED +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Inc;                                                                                        ../Drivers/STM32F1xx_HAL_Driver/Inc;                                                                                        ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;                                                                                        ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;                                                                                        ../Drivers/CMSIS/Include;                                                                                        ..\USER\App\inc;                                                                                        ..\USER\Bsp\inc;                                                                                        ..\USER\Module\inc;                                                                                        ..\USER\Other\inc;                                                                                        ..\USER\Protocol\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Application/User
    ../Src/: main.c gpio.c adc.c dac.c dma.c i2c.c rtc.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group App
    ../USER/App/src/: app_key.c app_pwm.c app_rtc.c app_adc.c app_dac.c app_i2c.c
  group Bsp
    ../USER/Bsp/src/: bsp_key.c bsp_uart.c bsp_iwdg.c bsp_wwdg.c bsp_tim.c bsp_pwm.c bsp_rtc.c bsp_standby.c bsp_systick.c bsp_adc.c bsp_dac.c
  group Module
    ../USER/Module/src/: module_basedevice.c module_uart.c
  group Protocol
    ../USER/Protocol/src/: protocol_remote_NEC.c protocol_serialport.c
  group Other
    ../USER/Other/src/: global_variable.c tool.c
    ../USER/Other/inc/: device_config.h
software components: CMSIS:CORE 4.3.0
